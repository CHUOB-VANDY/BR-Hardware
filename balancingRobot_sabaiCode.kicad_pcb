# Repository CHUOB-VANDY/BR-Hardware

## KiCad design balancingRobot_sabaiCode.kicad_pcb

Board: 4 copper layers, 80.0 x 80.0 mm, 119 parts (0 on the bottom side), 88 nets.

Parts:
ANT1: SWRA117D; Texas_SWRA117D_2.4GHz_Left
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 10uF; C_0805_2012Metric
C2, C3, C4, C8, C10, C11, C23, C25, C27, C28, C29, C31, C32, C35: 100nF; C_0603_1608Metric
C5: 220uF; CP_Elec_8x10.5
C6, C7: 20pF; C_0603_1608Metric
C9, C13, C14, C15, C24, C26: 10nF; C_0603_1608Metric
C12, C19: 2.2nF; C_0603_1608Metric
C16, C17: 22pF; C_0603_1608Metric
C18, C42: 33nF; C_0603_1608Metric
C20: 4.7pF; C_0603_1608Metric
C21: 1.5pF; C_0603_1608Metric
C22: 1pF; C_0603_1608Metric
C30, C33: 100uF; CP_Elec_8x10.5
C34, C36, C37, C40: 1uF; C_0603_1608Metric
C38, C39: 22uF; CP_EIA-3216-10_Kemet-I
C41: 330uF; CP_Elec_8x10.5
D1: BT_LED; LED_0603_1608Metric
D2: LED_M1; LED_0603_1608Metric
D3, D6: LED_M2; LED_0603_1608Metric
D4: SS34; D_SMA
D5: PC13_LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3mm_Pad_Via
J1: DCJ250-10-A_XX-X_REVA; BarrelJack_Horizontal
J2, J3: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: I2C; ConPadx04
J5: PWM_POW; PinHeader_2x04_P2.54mm_Vertical
J6: PWM_SIG; PinHeader_1x04_P2.54mm_Vertical
J7: ST-link; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
L1: 8.2nH; L_0603_1608Metric
L2, L4: 3.9nH; L_0603_1608Metric
L3: 2.7nH; L_0603_1608Metric
L5: 47uH; L_Bourns_SRR1260
Q1: Q_NPN_BEC; SOT-23
Q2: AO3401A; SOT-23
R1, R3, R11, R18, R19, R23, R24: 470R; R_0603_1608Metric
R2, R4, R10, R20, R21: 10k; R_0603_1608Metric
R5, R6, R7: 4.7k; R_0603_1608Metric
R8, R14, R16: 1M; R_0603_1608Metric
R9: 22k; R_0603_1608Metric
R12, R13, R15, R17: 0.25R; R_0805_2012Metric
R22: 3.3k; R_0603_1608Metric
RV1, RV2: 100k; Potentiometer_Bourns_TC33X_Vertical
RV3, RV4, RV5: 10k; Potentiometer_Vishay_T73YP_Vertical
SW1: AT_SW_Push; SW_SPST_TL3342
SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile
SW4: BTN; SW_SPST_TL3342
SW5: Reset; SW_SPST_TL3342
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32F031C6Tx; LQFP-48_7x7mm_P0.5mm
U2: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U3: NRF24L01; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U4: HC-05; XCVR_HC-05
U5, U6: DRV8825PWPR; IC_TPS61196PWPRQ1
U7: XL4015; TO-263-5_TabPin6
U8: AMS1117-3.3; SOT-223-3_TabPin2
Y1: 8Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 16Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C34.1, C35.1, L4.2, U1.9 (VDDA)
+3V3: BZ1.1 (-), C1.1, C2.1, C3.1, C4.1, C9.2, C10.1, C13.1, C14.1, C15.1, C23.2, C39.1, D6.2 (A), J4.3, J7.4, L4.1, R2.1, R5.2, R6.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, SW1.2, SW2.4, SW2.5, SW2.6, SW4.1, TP2.1, U1.1 (VBAT), U1.24 (VDD), U1.48 (VDD), U2.8 (VDDIO), U2.13 (VDD), U3.7 (VDD), U3.15 (VDD), U3.18 (VDD), U4.12 (3.3_VCC), U5.16 (~NRESET), U5.17 (NSLEEP), U6.16 (~NRESET), U6.17 (NSLEEP), U8.2 (VO)
+5V: C38.1, C40.1, C41.1, C42.1, J5.1, J5.3, J5.5, J5.7, L5.2, R21.1, U8.3 (VI)
/DVDD: C18.1, U3.19 (DVDD)
/Stepper Driver/M1_A1: J2.1, U5.5 (AOUT1)
/Stepper Driver/M1_A2: J2.2, U5.7 (AOUT2)
/Stepper Driver/M1_AVREF: RV1.2, U5.12 (AVREF), U5.13 (BVREF)
/Stepper Driver/M1_B1: J2.4, U5.10 (BOUT1)
/Stepper Driver/M1_B2: J2.3, U5.8 (BOUT2)
/Stepper Driver/M1_CP1: C24.1, U5.1 (CP1)
/Stepper Driver/M1_CP2: C24.2, U5.2 (CP2)
/Stepper Driver/M1_ISENA: R13.2, U5.6 (ISENA)
/Stepper Driver/M1_ISENB: R12.2, U5.9 (ISENB)
/Stepper Driver/M1_VCP: C25.1, R14.1, U5.3 (VCP)
/Stepper Driver/M2_A1: J3.1, U6.5 (AOUT1)
/Stepper Driver/M2_A2: J3.2, U6.7 (AOUT2)
/Stepper Driver/M2_AVREF: RV2.2, U6.12 (AVREF), U6.13 (BVREF)
/Stepper Driver/M2_B1: J3.4, U6.10 (BOUT1)
/Stepper Driver/M2_B2: J3.3, U6.8 (BOUT2)
/Stepper Driver/M2_CP1: C26.1, U6.1 (CP1)
/Stepper Driver/M2_CP2: C26.2, U6.2 (CP2)
/Stepper Driver/M2_ISENA: R17.2, U6.6 (ISENA)
/Stepper Driver/M2_ISENB: R15.2, U6.9 (ISENB)
/Stepper Driver/M2_VCP: C27.1, R16.1, U6.3 (VCP)
/XC1: C17.1, R8.1, U3.10 (XC1), Y2.1
/XC2: C16.1, R8.2, U3.9 (XC2), Y2.3
ADC0: RV3.2, U1.10 (PA0)
ADC1: RV4.2, U1.11 (PA1)
ADC2: RV5.2, U1.12 (PA2)
ANT1: L1.2, L3.2, U3.12 (ANT1)
ANT2: L1.1, L2.1, U3.13 (ANT2)
BOOT0: R4.1, U1.44 (BOOT0)
BTN: R20.1, SW4.2, U1.46 (PB9)
GND: ANT1.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C22.1, C23.1, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.2, C40.2, C41.2, D4.2 (A), J1.2, J1.3, J4.4, J5.2, J5.4, J5.6, J5.8, J7.1, Q1.2 (E), Q2.1 (G), R4.2, R7.2, R9.1, R10.1, R11.2, R12.1, R13.1, R15.1, R17.1, R18.2, R19.2, R20.2, R22.2, R23.2, R24.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, SW5.1, TP4.1, TP7.1, U1.8 (VSSA), U1.23 (VSS), U1.47 (VSS), U2.1 (CLKIN), U2.11 (FSYNC), U2.18 (GND), U3.8 (VSS), U3.14 (VSS), U3.17 (VSS), U3.20 (VSS)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
HSE_IN: C6.1, U1.5 (PF0), Y1.1
HSE_OUT: R1.2, U1.6 (PF1)
I2C_SCL: J4.1, R5.1, TP5.1, U1.21 (PB10), U2.23 (SCL)
I2C_SDA: J4.2, R6.2, TP6.1, U1.22 (PB11), U2.24 (SDA)
LED_PC13: D5.2 (A), U1.2 (PC13)
M1_DIR: U1.28 (PB15), U5.20 (DIR)
M1_EN: U1.27 (PB14), U5.21 (NENBL)
M1_LED: D2.2 (A), U1.32 (PA11)
M1_MODE0: SW2.1, U5.24 (MODE0), U6.24 (MODE0)
M1_MODE1: SW2.2, U5.25 (MODE1), U6.25 (MODE1)
M1_MODE2: SW2.3, U5.26 (MODE2), U6.26 (MODE2)
M1_STEP: U1.26 (PB13), U5.22 (STEP)
M2_DIR: U1.31 (PA10), U6.20 (DIR)
M2_EN: U1.30 (PA9), U6.21 (NENBL)
M2_LED: D3.2 (A), U1.33 (PA12)
M2_STEP: U1.29 (PA8), U6.22 (STEP)
MPU_INT: U1.20 (PB2), U2.12 (INT)
NRST: C8.1, R2.2, SW5.2, TP8.1, U1.7 (NRST)
unnamed: ANT1.1 (SIG), C21.2, C22.2
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C7.1, R1.1, Y1.3
unnamed: C11.2, U2.10 (REGOUT)
unnamed: C12.2, U2.20 (CPOUT)
unnamed: C21.1, L2.2
unnamed: C37.2, U7.4 (VC)
unnamed: C42.2, R21.2, R22.1, U7.2 (FB)
unnamed: D1.1 (K), R11.1
unnamed: D2.1 (K), R18.1
unnamed: D3.1 (K), R19.1
unnamed: D4.1 (K), L5.1, U7.3 (SW)
unnamed: D5.1 (K), R23.1
unnamed: D6.1 (K), R24.1
unnamed: J1.1, Q2.3 (D)
unnamed: Q1.1 (B), R3.2
unnamed: R7.1, U2.9 (AD0)
unnamed: R9.2, U3.16 (IREF)
PIO8: D1.2 (A), U4.31 (PIO[8])
PIO11: R10.2, SW1.1, U4.34 (PIO[11])
SPI_CE: U1.36 (PF7), U3.1 (CE)
SPI_CSS: U1.35 (PF6), U3.2 (CSN)
SPI_MISO: U1.40 (PB4), U3.5 (MISO)
SPI_MOSI: U1.41 (PB5), U3.4 (MOSI)
SPI_SCK: U1.39 (PB3), U3.3 (SCK)
SWCLK: J7.3, U1.37 (PA14)
SWDIO: J7.2, U1.34 (PA13)
TIM3_CH1: J6.1, U1.16 (PA6)
TIM3_CH2: J6.2, U1.17 (PA7)
TIM3_CH3: J6.3, U1.18 (PB0)
TIM3_CH4: J6.4, U1.19 (PB1)
TIM16_Buzzer: R3.1, U1.45 (PB8)
UART_RX: TP1.1, U1.43 (PB7), U4.1 (UART-TX)
UART_TX: TP3.1, U1.42 (PB6), U4.2 (UART-RX)
VCC: C5.1, C25.2, C27.2, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C36.1, C37.1, Q2.2 (S), R14.2, R16.2, U5.4 (VMA), U5.11 (VMB), U6.4 (VMA), U6.11 (VMB), U7.5 (VIN)
VDD_PA: C19.2, C20.2, L3.1, U3.11 (VDD_PA)
